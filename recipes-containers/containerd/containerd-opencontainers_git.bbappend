do_compile_prepend() {
    unset GOCACHE
}

